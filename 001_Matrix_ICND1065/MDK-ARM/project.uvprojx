# Keil uVision project project.uvprojx, settings and files
target MatrixDriver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER TEST_DEBUG
  c include: ..\Core\Inc;..\Drivers\cmsis\cm4\core_support;..\Drivers\cmsis\cm4\device_support;..\Drivers\drivers\inc;..\Drivers\BSP\board;..\Middlewares\usb_drivers\inc;..\Middlewares\usbd_class\cdc;..\usb_user;..\LGUI\Core;..\LGUI\User;..\Drivers\BSP\board\board_matrix;..\Core\utils;..\Core\utils\fonts
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../Core/Src/: main.c at32f435_437_clock.c at32f435_437_int.c SystemTimer.c image.c
    ../Core/utils/: matrix_string.c
    ../Core/utils/fonts/: Arial10.c
  group Drivers/BSP/Board
    ../Drivers/BSP/board/: board_delay.c board_led.c
    ../Drivers/BSP/board/board_matrix/: board_matrix.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ICND1065/: icnd1065.c
  group CMSIS
    ../Drivers/cmsis/cm4/device_support/: system_at32f435_437.c
    ./: startup_at32f435_437.s
  group firmware
    ../Drivers/drivers/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_xmc.c at32f435_437_usart.c at32f435_437_qspi.c at32f435_437_i2c.c at32f435_437_dma.c at32f435_437_adc.c at32f435_437_tmr.c at32f435_437_exint.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_spi.c
  group readme
    ../: readme.txt
